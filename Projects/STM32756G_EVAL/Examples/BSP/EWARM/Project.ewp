# IAR project Project.ewp, settings and files
configuration STM327x6G_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F756NG ST STM32F756NG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F756xx; USE_STM32756G_EVAL; USE_IOEXPANDER
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32756G_EVAL; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Utilities\Log; ..\..\..\..\..\Utilities\Fonts; ..\..\..\..\..\Utilities\CPU
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32756G_EVAL.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f756xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/exc7200/: exc7200.c
    ../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../../../Drivers/BSP/Components/ts3510/: ts3510.c
  group Drivers/BSP/STM327x6G_EVAL
    ../../../../../Drivers/BSP/STM32756G_EVAL/: stm32756g_eval.c stm32756g_eval_eeprom.c stm32756g_eval_io.c stm32756g_eval_lcd.c stm32756g_eval_nor.c stm32756g_eval_sd.c stm32756g_eval_sdram.c stm32756g_eval_sram.c stm32756g_eval_ts.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_nor.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c
  group Example/EWARM
    ./: startup_stm32f756xx.s
  group Example/User
    ../Src/: eeprom.c joystick.c lcd.c log.c main.c nor.c sd.c sdram.c sram.c stm32f7xx_it.c touchscreen.c ts_calibration.c
  group Utilities
    ../../../../../Utilities/Log/: lcd_log.c
