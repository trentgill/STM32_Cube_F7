# Keil uVision project Project.uvprojx, settings and files
target STM32F7_Demo (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F756NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32F7_Demo +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F756xx,USE_HAL_DRIVER,USE_STM32756G_EVAL,USE_USB_HS,USE_IOEXPANDER
  c misc: --C99
  c include: ../STemWin_Addons;../Config;../Core/inc;../../../../Utilities/CPU;../../../../Drivers/CMSIS/Include;../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32756G_EVAL;../../../../Drivers/BSP/Components;../../../../Drivers/BSP/Components/Common;../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;../../../../Middlewares/ST/STemWin/inc;../../../../Middlewares/Third_Party/FatFs/src;../../../../Middlewares/Third_Party/FatFs/src/drivers;../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Modules/audio_player/Addons/SpiritDSP_Equalizer;../Modules/audio_player/Addons/SpiritDSP_LoudnessControl
  asm include: ROJ_DIR$\..\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: STM32F7_Demo\STM32F7_Demo.sct
  group Application/User/Core
    ../Core/Src/: k_bsp.c stm32f7xx_hal_timebase_tim.c k_modules_res.c stm32f7xx_it.c main.c k_menu.c k_rtc.c k_startup.c k_module.c k_storage.c
  group Doc
    ../: readme.txt
  group Application/User/Modules/VideoPlayer
    ../Modules/videoplayer/: GUI_AVI.c video_player_win.c
  group Middlewares/STemWin/Library
    ../../../../Middlewares/ST/STemWin/Lib/: STemWin532_CM7_OS_Keil_ot.lib
  group Middlewares/FreeRTOS/Portable
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Drivers/BSP/Component
    ../../../../Drivers/BSP/Components/ts3510/: ts3510.c
    ../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../Drivers/BSP/Components/wm8994/: wm8994.c
    ../../../../Drivers/BSP/Components/exc7200/: exc7200.c
    ../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Middlewares/USBH_Library/Core
    ../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_pipes.c usbh_core.c usbh_ioreq.c usbh_ctlreq.c
  group Application/User/Modules/Audio
    ../Modules/audio_player/: audio_player_win.c audio_player_app.c
  group Middlewares/FatFs/Core
    ../../../../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c ff.c diskio.c
  group Middlewares/USBH_Library/Class/MSC
    ../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_scsi.c usbh_msc_bot.c
  group Application/User/Modules/gardening_control
    ../Modules/gardening_control/: gardening_control_win.c
  group Middlewares/FatFs/Options
    ../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/FatFs/Drivers
    ../../../../Middlewares/Third_Party/FatFs/src/drivers/: usbh_diskio.c
  group Middlewares/STemWin/Config
    ../Config/: LCDConf.c GUIConf.c
  group Middlewares/STemWin/OS
    ../Config/: GUI_X_FreeRTOS.c
    ../../../../Middlewares/ST/STemWin/OS/: GUI_X_OS.c
  group Middlewares/PDM
    ../../../../Middlewares/ST/STM32_Audio/Addons/PDM/: libPDMFilter_CM7_Keil.lib
  group Drivers/BSP/STM32756G_EVAL
    ../../../../Drivers/BSP/STM32756G_EVAL/: stm32756g_eval_ts.c stm32756g_eval_sdram.c stm32756g_eval_nor.c stm32756g_eval_io.c stm32756g_eval.c stm32756g_eval_audio.c
  group Middlewares/FreeRTOS
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c croutine.c queue.c list.c timers.c tasks.c
  group Application/User/Modules/home_alarm
    ../Modules/home_alarme/: home_alarm_win.c
  group Middlewares/USBH_Library/Config
    ../Config/: usbh_conf.c
  group Drivers/STM32F7xx_HAL_Drivers
    ../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_ltdc.c stm32f7xx_hal_lptim.c stm32f7xx_hal_pcd.c stm32f7xx_hal_i2s.c stm32f7xx_hal_tim.c stm32f7xx_hal_irda.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_wwdg.c stm32f7xx_hal_rcc_ex.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_hash.c stm32f7xx_hal_nor.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_gpio.c stm32f7xx_hal_usart.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_crc.c stm32f7xx_hal_cryp.c stm32f7xx_hal_hcd.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_sdram.c stm32f7xx_hal_pwr.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sram.c stm32f7xx_ll_usb.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_flash.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp_ex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_rtc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_qspi.c stm32f7xx_hal_adc.c stm32f7xx_hal_rcc.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_spi.c stm32f7xx_hal_can.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_dma.c stm32f7xx_hal_rng.c stm32f7xx_hal.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Application/User/Modules/settings
    ../Modules/settings/: settings_win.c
  group Application/User/Utilities
    ../../../../Utilities/CPU/: cpu_utils.c
  group Application/User/Modules/Audio/Addons
    ../Modules/audio_player/Addons/SpiritDSP_Equalizer/: lib_equalizer_cortex_m4.a
    ../Modules/audio_player/Addons/SpiritDSP_LoudnessControl/: lib_loudness_cortex_m4.a
  group Application/MDK-ARM
    ./: startup_stm32f756xx.s
  group Application/User/Modules/games
    ../Modules/games/: games_win.c
  group Middlewares/ST_Widgets
    ../STemWin_Addons/: STM32756G_EVAL_STemWin_Addons_Keil.lib
software components: CMSIS:CORE 4.3.0
