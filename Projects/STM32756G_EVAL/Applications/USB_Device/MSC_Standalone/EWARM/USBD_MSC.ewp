# IAR project USBD_MSC.ewp, settings and files
configuration STM327x6G-EVAL_USBD-FS (ARM, debug)
  General.OGChipSelectEditMenu: STM32F756NG ST STM32F756NG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F756xx; USE_STM32756G_EVAL; USE_IOEXPANDER; USE_USB_FS
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc; ..\..\..\..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32756G_EVAL; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32756G-EVAL_USBD-FS.hex
  ILINK.IlinkOutputFile: STM32756G-EVAL_USBD-FS.out
  ILINK.IlinkIcfFile: stm32f756xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM327x6G-EVAL_USBD-HS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F756xx; USE_STM32756G_EVAL; USE_IOEXPANDER; USE_USB_HS
  OBJCOPY.OOCOutputFile: STM32756G-EVAL_USBD-HS.hex
  ILINK.IlinkOutputFile: STM32756G-EVAL_USBD-HS.out
configuration STM327x6G-EVAL_USBD-HS-IN-FS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F756xx; USE_STM32756G_EVAL; USE_IOEXPANDER; USE_USB_HS; USE_USB_HS_IN_FS
  OBJCOPY.OOCOutputFile: STM32756G-EVAL_USBD-HS-IN-FS.hex
  ILINK.IlinkOutputFile: STM32756G-EVAL_USBD-HS-IN-FS.out
  group Application/EWARM
    ./: startup_stm32f756xx.s
  group Application/User
    ../Src/: main.c stm32f7xx_it.c usbd_conf.c usbd_desc.c usbd_storage.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group Drivers/BSP/STM32756G-EVAL
    ../../../../../../Drivers/BSP/STM32756G_EVAL/: stm32756g_eval.c stm32756g_eval_io.c stm32756g_eval_sd.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
  group Middlewares/STM32_USBD_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
