# Keil uVision project Project.uvprojx, settings and files
target STM327x6G_EVAL_MB1063 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F756NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM327x6G_EVAL_MB1063
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F756xx,USE_STM32756G_EVAL,USE_IOEXPANDER,USE_MB1063
  c misc: --C99
  c include: ../Inc;../Demo;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32756G_EVAL;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components;../../../../../../Middlewares/ST/STemWin/inc;../../../../../../Utilities;../../../../../../Utilities/Fonts
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ts3510/: ts3510.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../../../../Drivers/BSP/Components/exc7200/: exc7200.c
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group Middlewares/STemWin/Config
    ../Src/: LCDConf_stm32756g_eval_MB1063.c GUIConf.c
    ../../../../../../Middlewares/ST/STemWin/OS/: GUI_X.c
  group Drivers/BSP/STM32756G_EVAL
    ../../../../../../Drivers/BSP/STM32756G_EVAL/: stm32756g_eval_ts.c stm32756g_eval_sdram.c stm32756g_eval.c stm32756g_eval_io.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/STemWin/Lib
    ../../../../../../Middlewares/ST/STemWin/Lib/: STemWin532_CM7_Keil.lib
  group Application/MDK-ARM
    ./: startup_stm32f756xx.s
  group Application/User
    ../Src/: rtc.c main.c calibration.c stm32f7xx_it.c
  group Doc
    ../: readme.txt
  group Application/Demo
    ../Demo/: GUIDEMO_Conf.c GUIDEMO_Bitmap.c GUIDEMO_Graph.c GUIDEMO.c GUIDEMO_Resource.c GUIDEMO_Cursor.c GUIDEMO_Start.c GUIDEMO_VScreen.c GUIDEMO_IconView.c GUIDEMO_Intro.c GUIDEMO_Speed.c GUIDEMO_RadialMenu.c GUIDEMO_Treeview.c GUIDEMO_ColorBar.c GUIDEMO_Listview.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_tim.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_crc.c stm32f7xx_hal_rcc.c stm32f7xx_hal_sdram.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_dma2d.c stm32f7xx_hal.c stm32f7xx_hal_flash.c stm32f7xx_hal_cortex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_adc.c stm32f7xx_hal_rng.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_uart.c stm32f7xx_hal_i2c.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_tim_ex.c
software components: CMSIS:CORE 4.3.0
