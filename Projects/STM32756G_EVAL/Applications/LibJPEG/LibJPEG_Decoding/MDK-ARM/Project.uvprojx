# Keil uVision project Project.uvprojx, settings and files
target STM327x6G_EVAL (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F756NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.2
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM327x6G_EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F756xx,USE_STM32756G_EVAL,USE_IOEXPANDER
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32756G_EVAL;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Middlewares/Third_Party/FatFs/src/drivers;../../../../../../Middlewares/Third_Party/LibJPEG/include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Middlewares/FatFs/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group Doc
    ../: readme.txt
  group Application/MDK-ARM
    ./: startup_stm32f756xx.s
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_ll_sdmmc.c stm32f7xx_hal_pwr.c stm32f7xx_hal_adc.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_sdram.c stm32f7xx_hal_i2c.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_rcc.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal.c stm32f7xx_hal_gpio.c stm32f7xx_hal_ltdc.c stm32f7xx_ll_fmc.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_dma.c stm32f7xx_hal_cortex.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c diskio.c ff.c
  group Application/User
    ../Src/: main.c stm32f7xx_it.c jdata_conf.c decode.c
  group Middlewares/Lib_JPEG
    ../../../../../../Middlewares/Third_Party/LibJPEG/source/: jcmarker.c jdarith.c jdtrans.c jcmaster.c jcmainct.c jdapistd.c jcsample.c jfdctflt.c jdapimin.c jmemnobs.c jcinit.c jfdctint.c jddctmgr.c jdinput.c jdatasrc.c jcomapi.c jcapistd.c jidctflt.c jdmaster.c jcprepct.c jdmainct.c jdcoefct.c jdsample.c jcarith.c jerror.c jaricom.c jmemmgr.c jccolor.c jdatadst.c jquant1.c jdmerge.c jcparam.c jutils.c jccoefct.c jquant2.c jchuff.c jidctfst.c jdpostct.c jdmarker.c jcapimin.c jdcolor.c jidctint.c jdhuff.c jcdctmgr.c jctrans.c jfdctfst.c
  group Drivers/BSP/STM32756G_EVAL
    ../../../../../../Drivers/BSP/STM32756G_EVAL/: stm32756g_eval_sd.c stm32756g_eval_lcd.c stm32756g_eval_io.c stm32756g_eval.c stm32756g_eval_sdram.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
software components: CMSIS:CORE 4.3.0
