# Keil uVision project Project.uvprojx, settings and files
target STM32F769I_Discovery_USBH (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.3.3
  cpu: IROM(0x08000000-0x081FFFFF) IRAM(0x20000000-0x2007FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32F769I_Discovery_USBH
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F769xx,USE_STM32769I_DISCO,USE_USB_HS
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../../../Drivers/BSP/STM32F769I-Discovery;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Utilities/Log
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM32F769I_Discovery
    ../../../../../../Drivers/BSP/STM32F769I-Discovery/: stm32f769i_discovery_lcd.c stm32f769i_discovery_sdram.c stm32f769i_discovery_sd.c stm32f769i_discovery.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
  group Application/MDK-ARM
    ./: startup_stm32f769xx.s
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_pwr.c stm32f7xx_hal_cortex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_sd.c stm32f7xx_hal_ltdc.c stm32f7xx_ll_usb.c stm32f7xx_hal_dsi.c stm32f7xx_hal_hcd.c stm32f7xx_hal_flash.c stm32f7xx_hal.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_rcc.c stm32f7xx_ll_fmc.c stm32f7xx_hal_dma.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_sram.c stm32f7xx_hal_pwr_ex.c
  group Doc
    ../: readme.txt
  group Application/User
    ../Src/: explorer.c usbh_conf.c main.c stm32f7xx_it.c usbh_diskio.c file_operations.c menu.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/FatFS
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_pipes.c usbh_ioreq.c usbh_ctlreq.c
  group Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
software components: CMSIS:CORE 4.3.0
