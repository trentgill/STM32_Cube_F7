# Keil uVision project Project.uvprojx, settings and files
target STM32F769I_Discovery (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32F769I_Discovery
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F769xx,USE_HAL_DRIVER,USE_STM32F769I_DISCO,DATA_IN_ExtSDRAM,USE_LCD_HDMI
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F769I-Discovery;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Middlewares/Third_Party/FatFs/src/drivers;../../../../../../Utilities/JPEG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Doc
    ../: readme.txt
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_dma2d.c stm32f7xx_hal_ltdc.c stm32f7xx_hal.c stm32f7xx_hal_rcc.c stm32f7xx_hal_sd.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_sdram.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_dsi.c stm32f7xx_hal_jpeg.c stm32f7xx_ll_fmc.c stm32f7xx_hal_gpio.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_dma.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/FatFs/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Example/MDK-ARM
    ./: startup_stm32f769xx.s
  group Example/User
    ../Src/: stm32f7xx_hal_msp.c decode_dma.c main.c stm32f7xx_it.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/adv7533/: adv7533.c
    ../../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
  group Drivers/BSP/STM32F769I_Discovery
    ../../../../../../Drivers/BSP/STM32F769I-Discovery/: stm32f769i_discovery.c stm32f769i_discovery_lcd.c stm32f769i_discovery_sdram.c stm32f769i_discovery_sd.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff.c ff_gen_drv.c diskio.c
  group Utilities
    ../../../../../../Utilities/JPEG/: jpeg_utils.c
software components: CMSIS:CORE 4.3.0
