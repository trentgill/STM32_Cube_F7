# Keil uVision project Project.uvprojx, settings and files
target STM32F723E-DISCO_Demo (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F723IEKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.1
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x8000000-0x807FFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32F723E-DISCO_Demo +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F723xx,USE_STM32F723E_DISCO,USE_USB_HS
  c misc: --C99
  c include: ../STemWin_Addons;../Config;../Core/inc;../../../../Utilities/CPU;../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32F723E-Discovery;../../../../Drivers/BSP/Components;../../../../Drivers/BSP/Components/Common;../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../Middlewares/ST/STemWin/inc;../../../../Middlewares/Third_Party/FatFs/src;../../../../Middlewares/Third_Party/FatFs/src/drivers;../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Modules/Common
  asm include: ROJ_DIR$\..\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: STM32F723E-DISCO_Demo\STM32F723E-DISCO_Demo.sct
  group Application/User/Modules/Analog_Clock
    ../Modules/analog_clock/: analog_clock_win.c
  group Application/User/Modules/Info
    ../Modules/information/: information_win.c
  group Middlewares/STemWin/Library
    ../../../../Middlewares/ST/STemWin/Lib/: STemWin532_CM7_OS_IAR_ot.a
  group Middlewares/USBH_Library/Class/MSC
    ../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Middlewares/FatFs/Drivers
    ../../../../Middlewares/Third_Party/FatFs/src/drivers/: usbh_diskio.c
  group Application/User/Core
    ../Core/Src/: k_menu.c main.c k_startup.c k_module.c stm32f7xx_it.c k_storage.c k_bsp.c k_rtc.c k_calibration.c
  group Middlewares/STemWin/ST_GUI_Addons
    ../STemWin_Addons/: STM32F723E_DISCO_STemWin_Addons_Keil.lib
  group Application/User/Modules/Audio_recorder
    ../Modules/audio_recorder/: audio_recorder_app.c audio_recorder_win.c
  group Application/User/Modules/VideoPlayer
    ../Modules/videoplayer/: GUI_AVI.c video_player_win.c
  group Drivers/BSP/STM32723E_DISCO
    ../../../../Drivers/BSP/STM32F723E-Discovery/: stm32f723e_discovery_qspi.c stm32f723e_discovery_audio.c stm32f723e_discovery_lcd.c stm32f723e_discovery.c stm32f723e_discovery_ts.c
  group Middlewares/PDM
    ../../../../Middlewares/ST/STM32_Audio/Addons/PDM/: libPDMFilter_CM7_Keil.lib
  group Middlewares/USBH_Library/Core
    ../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ioreq.c usbh_ctlreq.c usbh_pipes.c
  group Application/User/Modules/Audio
    ../Modules/audio_player/: audio_player_win.c audio_player_app.c
  group Application/User/Modules/common
    ../Modules/Common/: audio_if.c
  group Middlewares/STemWin/Config
    ../Config/: GUIConf.c LCDConf.c
  group Application/User/Utilities
    ../../../../Utilities/CPU/: cpu_utils.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Middlewares/USBH_Library/Config
    ../Config/: usbh_conf.c
  group Application/MDK-ARM
    ./: startup_stm32f723xx.s
  group Drivers/BSP/Component
    ../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
    ../../../../Drivers/BSP/Components/st7789h2/: st7789h2.c
    ../../../../Drivers/BSP/Components/wm8994/: wm8994.c
  group Middlewares/FatFs/Options
    ../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/FreeRTOS
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/: queue.c croutine.c timers.c tasks.c list.c event_groups.c
  group Middlewares/FreeRTOS/Portable
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FatFs/Core
    ../../../../Middlewares/Third_Party/FatFs/src/: ff.c diskio.c ff_gen_drv.c
  group Middlewares/STemWin/OS
    ../../../../Middlewares/ST/STemWin/OS/: GUI_X_OS.c
  group Drivers/STM32F7xx_HAL_Drivers
    ../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_dma_ex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_dma.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pcd.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_rcc.c stm32f7xx_hal_hcd.c stm32f7xx_ll_usb.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_sai.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_sram.c stm32f7xx_hal_sdram.c stm32f7xx_hal_uart.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_pwr.c stm32f7xx_hal.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.3.0
