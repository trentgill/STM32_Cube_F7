# IAR project USBD_HID.ewp, settings and files
configuration STM32F723E-DISCOVERY_USBD-HS (ARM, debug)
  General.OGChipSelectEditMenu: STM32F723IE  ST STM32F723IE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F723xx; USE_STM32F723E_DISCO; USE_USB_HS
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc; ..\..\..\..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F723E-Discovery; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F723E-DISCOVERY_USBD-HS.hex
  ILINK.IlinkOutputFile: STM32F723E-DISCOVERY_USBD-HS.out
  ILINK.IlinkIcfFile: stm32f723xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F723E-DISCOVERY_USBD-FS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F723xx; USE_STM32F723E_DISCO; USE_USB_FS
  OBJCOPY.OOCOutputFile: STM32F723E-DISCOVERY_USBD-FS.hex
  ILINK.IlinkOutputFile: STM32F723E-DISCOVERY_USBD-FS.out
  group Application/EWARM
    ./: startup_stm32f723xx.s
  group Application/User
    ../Src/: main.c stm32f7xx_it.c usbd_conf.c usbd_desc.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32723E_DISCOVERY
    ../../../../../../Drivers/BSP/STM32F723E-Discovery/: stm32f723e_discovery.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sram.c stm32f7xx_hal_uart.c stm32f7xx_ll_fmc.c stm32f7xx_ll_usb.c
  group Middlewares/STM32_USBD_Library/Class/HID
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
