# Keil uVision project Project.uvprojx, settings and files
target STM32F723E_DISCOVERY_USBH-FS (ARM-ADS)
  device: STM32F723IEKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.1
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x8000000-0x807FFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32F723E_DISCOVERY_USBH-FS
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F723xx,USE_STM32F723E_DISCO,USE_USB_FS
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../../../Drivers/BSP/STM32F723E-Discovery;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Utilities/Log
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Application/MDK-ARM
    ./: startup_stm32f723xx.s
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc_bot.c usbh_msc.c usbh_msc_scsi.c
  group Doc
    ../: readme.txt
  group Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
  group Middlewares/FatFS
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
    ../../../../../../Drivers/BSP/Components/st7789h2/: st7789h2.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_ctlreq.c usbh_pipes.c usbh_core.c usbh_ioreq.c
  group Application/User
    ../Src/: file_operations.c usbh_conf.c menu.c explorer.c usbh_diskio.c main.c ts_calibration.c stm32f7xx_it.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_cortex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_flash.c stm32f7xx_hal_dma.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_sd.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_i2c.c stm32f7xx_hal_rcc.c stm32f7xx_hal_dsi.c stm32f7xx_hal_hcd.c stm32f7xx_hal_pwr.c stm32f7xx_hal_rcc_ex.c stm32f7xx_ll_usb.c stm32f7xx_ll_fmc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_gpio.c stm32f7xx_hal_sram.c
  group Drivers/BSP/STM32F723E-Discovery
    ../../../../../../Drivers/BSP/STM32F723E-Discovery/: stm32f723e_discovery_lcd.c stm32f723e_discovery.c stm32f723e_discovery_ts.c
target STM32F723E_DISCOVERY_USBH-HS (ARM-ADS)
  device: STM32F723IEKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.1
  cpu: as above
  output: STM32F723E_DISCOVERY_USBH-HS
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F723xx,USE_STM32F723E_DISCO,USE_USB_HS
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
software components: CMSIS:CORE 4.3.0
