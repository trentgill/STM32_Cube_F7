# Keil uVision project Project.uvprojx, settings and files
target STM32F723E_Discovery (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F723IEKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.1
  cpu: IRAM(0x20000000,0x40000) IROM(0x08000000,0x80000) IROM2(0x00200000,0x80000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32F723E_Discovery
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F723xx,USE_STM32F723E_Discovery,USE_USB_HS
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F723E-Discovery;../../../../../../Utilities;../../../../../../Utilities/fonts;../../../../../../Utilities/Log;../../../../../../Drivers/BSP/Components;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Middlewares/Third_Party/FatFs/src/drivers;../../../../../../Middlewares/Third_Party/LibJPEG/include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x200000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Application/MDK-ARM
    ./: startup_stm32f723xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/st7789h2/: st7789h2.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
  group Lib_JPEG
    ../../../../../../Middlewares/Third_Party/LibJPEG/source/: jdatasrc.c jccolor.c jidctint.c jcapimin.c jdsample.c jdtrans.c jfdctint.c jquant1.c jcparam.c jcprepct.c jcarith.c jdmaster.c jcomapi.c jdmerge.c jcmaster.c jdapistd.c jddctmgr.c jcapistd.c jmemmgr.c jchuff.c jdcolor.c jdmainct.c jutils.c jcinit.c jdhuff.c jdarith.c jdapimin.c jaricom.c jidctflt.c jdatadst.c jcmarker.c jdmarker.c jccoefct.c jerror.c jcmainct.c jfdctfst.c jctrans.c jdinput.c jmemnobs.c jcsample.c jidctfst.c jdpostct.c jquant2.c jfdctflt.c jcdctmgr.c jdcoefct.c
  group Drivers/BSP/STM32F723E_Discovery
    ../../../../../../Drivers/BSP/STM32F723E-Discovery/: stm32f723e_discovery.c stm32f723e_discovery_psram.c stm32f723e_discovery_lcd.c
  group Doc
    ../: readme.txt
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_sram.c stm32f7xx_hal_rcc.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pcd.c stm32f7xx_hal_flash_ex.c stm32f7xx_ll_usb.c stm32f7xx_hal_sd.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_dma_ex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_sdram.c stm32f7xx_hal_dsi.c stm32f7xx_hal_flash.c stm32f7xx_hal_i2c.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma2d.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_adc.c stm32f7xx_hal_dma.c stm32f7xx_hal_uart.c
  group Middlewares/FatFs/Drivers
    ../Src/: usbh_diskio.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc_scsi.c usbh_msc_bot.c usbh_msc.c
  group Application/User
    ../Src/: stm32f7xx_it.c usbh_conf.c jdata_conf.c main.c decode.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_ioreq.c usbh_core.c usbh_pipes.c usbh_ctlreq.c
software components: CMSIS:CORE 4.3.0
