# Keil uVision project Project.uvprojx, settings and files
target STM32F767ZI_Nucleo (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.3.3
  cpu: IROM(0x08000000-0x081FFFFF) IRAM(0x20000000-0x2007FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32F767ZI_Nucleo
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F767xx,USE_HAL_DRIVER,USE_STM32F7XX_NUCLEO_144,ADAFRUIT_TFT_JOY_SD_ID802
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP//STM32F7xx_Nucleo_144;../../../../../../Drivers/BSP/Components;../../../../../../Drivers/BSP/Adafruit_Shield;../../../../../../Drivers/BSP/Components/st7735;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Middlewares/Third_Party/FatFs/src/drivers
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_flash.c stm32f7xx_hal_cortex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_ll_fmc.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_sd.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_spi.c stm32f7xx_hal_sdram.c stm32f7xx_hal_i2c.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_uart.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_pwr.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/FatFs/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Drivers/BSP/Adafruit_Shield
    ../../../../../../Drivers/BSP/Adafruit_Shield/: stm32_adafruit_lcd.c stm32_adafruit_sd.c
  group Application/User
    ../Src/: main.c stm32f7xx_it.c
  group Application/MDK-ARM
    ./: startup_stm32f767xx.s
  group Drivers/BSP/STM32F7xx_Nucleo
    ../../../../../../Drivers/BSP/STM32F7xx_Nucleo_144/: stm32f7xx_nucleo_144.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/st7735/: st7735.c
software components: CMSIS:CORE 4.3.0
