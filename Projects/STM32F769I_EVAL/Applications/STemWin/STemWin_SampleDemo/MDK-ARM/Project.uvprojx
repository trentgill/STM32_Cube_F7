# Keil uVision project Project.uvprojx, settings and files
target STM32F769I_EVAL (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.1
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32F769I_EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F769xx,USE_STM32F769I_EVAL,USE_IOEXPANDER
  c misc: --C99
  c include: ../Inc;../Demo;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F769I_EVAL;../../../../../../Drivers/BSP/Components/mfxstm32l152;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components;../../../../../../Middlewares/ST/STemWin/inc;../../../../../../Utilities;../../../../../../Utilities/Fonts
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Doc
    ../: readme.txt
  group Middlewares/STemWin/Lib
    ../../../../../../Middlewares/ST/STemWin/Lib/: STemWin532_CM7_Keil.lib
  group Drivers/BSP/STM32769I_EVAL
    ../../../../../../Drivers/BSP/STM32F769I_EVAL/: stm32f769i_eval.c stm32f769i_eval_sdram.c stm32f769i_eval_ts.c stm32f769i_eval_io.c
  group Application/Demo
    ../Demo/: GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO.c GUIDEMO_RadialMenu.c GUIDEMO_VScreen.c GUIDEMO_ColorBar.c GUIDEMO_Listview.c GUIDEMO_Treeview.c GUIDEMO_Automotive.c GUIDEMO_Intro.c GUIDEMO_Start.c GUIDEMO_Conf.c GUIDEMO_Resource.c GUIDEMO_Speed.c GUIDEMO_Cursor.c GUIDEMO_TransparentDialog.c GUIDEMO_Bitmap.c
  group Application/MDK-ARM
    ./: startup_stm32f769xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Application/User
    ../Src/: main.c rtc.c stm32f7xx_it.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_ltdc.c stm32f7xx_hal_uart.c stm32f7xx_hal_dsi.c stm32f7xx_hal_i2c.c stm32f7xx_hal.c stm32f7xx_hal_tim.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_adc.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_adc_ex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rtc.c stm32f7xx_hal_pwr.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_crc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_gpio.c
  group Middlewares/STemWin/Config
    ../Src/: LCDConf_stm32f769i_eval.c GUIConf_stm32f769i_eval.c
    ../../../../../../Middlewares/ST/STemWin/OS/: GUI_X.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
software components: CMSIS:CORE 4.3.0
