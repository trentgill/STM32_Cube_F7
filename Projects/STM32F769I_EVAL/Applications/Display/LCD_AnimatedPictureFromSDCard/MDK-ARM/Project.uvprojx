# Keil uVision project Project.uvprojx, settings and files
target STM32F769I_EVAL (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.3.3
  cpu: IROM(0x08000000-0x081FFFFF) IRAM(0x20000000-0x2007FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32F769I_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F769xx,USE_STM32F769I_EVAL,USE_IOEXPANDER
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F769I_EVAL;../../../../../../Utilities;../../../../../../Utilities/fonts;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Drivers/BSP/Components;../../../../../../Drivers/BSP/Components/otm8009a;../../../../../../Middlewares/Third_Party/FatFs/src/drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Middlewares/FatFs/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Application/MDK-ARM
    ./: startup_stm32f769xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Application/User
    ../Src/: fatfs_storage.c main.c stm32f7xx_it.c
  group Drivers/BSP/STM32F769I_EVAL
    ../../../../../../Drivers/BSP/STM32F769I_EVAL/: stm32f769i_eval.c stm32f769i_eval_io.c stm32f769i_eval_lcd.c stm32f769i_eval_sdram.c stm32f769i_eval_sd.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_ltdc.c stm32f7xx_ll_fmc.c stm32f7xx_hal_uart.c stm32f7xx_hal_pwr_ex.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_dsi.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_rcc.c stm32f7xx_hal_i2c.c stm32f7xx_hal.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_adc.c stm32f7xx_hal_pwr.c stm32f7xx_hal_cortex.c stm32f7xx_hal_sd.c stm32f7xx_hal_dma.c stm32f7xx_hal_flash.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_adc_ex.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
software components: CMSIS:CORE 4.3.0
