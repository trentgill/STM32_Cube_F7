# Keil uVision project Project.uvprojx, settings and files
target STM32F779I_EVAL (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F779NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.3.3
  cpu: IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32F779I_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F779xx,USE_STM32F769I_EVAL
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F769I_EVAL;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Log;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --diag_suppress=L6329
  group Example/MDK-ARM
    ./: startup_stm32f779xx.s
  group Example/User
    ../Src/: main.c stm32f7xx_it.c stm32f7xx_hal_msp.c
  group Doc
    ../: readme.txt Expected_Results.txt
  group Drivers/BSP/STM32F769I_EVAL
    ../../../../../../Drivers/BSP/STM32F769I_EVAL/: stm32f769i_eval.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_gpio.c stm32f7xx_hal_uart.c stm32f7xx_hal_adc.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_cryp.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_adc_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
software components: CMSIS:CORE 4.3.0
