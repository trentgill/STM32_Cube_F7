# Keil uVision project Project.uvprojx, settings and files
target STM32746G-DISCOVERY_USBD-FS (ARM-ADS)
  device: STM32F746NGHx STMicroelectronics
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32746G-DISCOVERY_USBD-FS
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,USE_STM32746G_DISCO,USE_USB_FS
  c misc: --C99
  c include: ../Inc;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32746G-Discovery;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/CMSIS/Include
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Middlewares/STM32_USBD_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s startup_stm32f746xx.s
  group Application/User
    ../Src/: stm32f7xx_it.c usbd_desc.c usbd_storage.c usbd_conf.c main.c stm32f7xx_it.c usbd_desc.c usbd_storage.c usbd_conf.c main.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_usart.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_sd.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_pwr.c stm32f7xx_hal.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_dma.c stm32f7xx_ll_usb.c stm32f7xx_hal_pcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_pwr_ex.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_rcc.c stm32f7xx_hal_cortex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_usart.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_sd.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_pwr.c stm32f7xx_hal.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_dma.c stm32f7xx_ll_usb.c stm32f7xx_hal_pcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_pwr_ex.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_rcc.c stm32f7xx_hal_cortex.c stm32f7xx_hal_gpio.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c usbd_core.c usbd_ctlreq.c usbd_ioreq.c usbd_core.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c system_stm32f7xx.c
  group Drivers/BSP/STM32746G_DISCOVERY
    ../../../../../../Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery_sd.c stm32746g_discovery.c stm32746g_discovery_sd.c stm32746g_discovery.c
  group Doc
    ../: readme.txt readme.txt
target STM32746G-DISCOVERY_USBD-HS (ARM-ADS)
  device: STM32F746NGHx STMicroelectronics
  cpu: as above
  output: STM32746G-DISCOVERY_USBD-HS
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,USE_STM32746G_DISCO,USE_USB_HS
  c misc: --C99
  c include: as above
  library: MicroLIB
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 4.3.0
