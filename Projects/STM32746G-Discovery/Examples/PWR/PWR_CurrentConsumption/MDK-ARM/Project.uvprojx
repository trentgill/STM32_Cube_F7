# Keil uVision project Project.uvprojx, settings and files
target STM32F746G-Discovery (ARM-ADS)
  device: STM32F746NGHx STMicroelectronics
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32F746G-Discovery
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F756xx,USE_STM32746G_DISCOVERY
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32746G-Discovery
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Example/MDK-ARM
    ./: startup_stm32f746xx.s
  group Drivers/BSP/STM32F746G-Discovery
    ../../../../../../Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c
  group Doc
    ../: readme.txt
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_gpio.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_flash.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_cortex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_spi.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rcc.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Example/User
    ../Src/: main.c stm32f7xx_lp_modes.c stm32f7xx_it.c stm32f7xx_hal_msp.c
software components: CMSIS:CORE 4.3.0
